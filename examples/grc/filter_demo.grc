options:
  parameters:
    generate_options: qt_gui
    id: fft_filter_demo
    output_language: python
    title: FFT Filter Demo
  states: {}

blocks:
- name: bp_high
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: bp_low
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: bp_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: bp_high
    low_cutoff_freq: bp_low
    samp_rate: samp_rate
    type: band_pass
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: int(-samp_rate / 2)
    step: '1'
    stop: int(samp_rate / 2)
    value: '1000'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate / 4
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate / 10
    win: window.WIN_BLACKMAN
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '-12345'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cuda_fft_filter_xxx_0
  id: cuda_fft_filter_xxx
  parameters:
    decim: '1'
    samp_delay: '0'
    taps: lp_taps
    type: ccf
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lp_taps
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '0.5'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '65536'
    srate: '1'
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', cuda_fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', fft_filter_xxx_0, '0']
- [cuda_fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [cuda_fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
