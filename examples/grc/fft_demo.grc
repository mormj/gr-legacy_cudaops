options:
  parameters:
    generate_options: qt_gui
    id: fft_demo
    output_language: python
    title: FFT Demo
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: int(-samp_rate / 2)
    step: '1'
    stop: int(samp_rate / 2)
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: legacy_cudaops_fft_0
  id: legacy_cudaops_fft
  parameters:
    batch_size: '1'
    fft_size: fft_size
    forward: 'True'
    memory_model: legacy_cudaops.memory_model_t.TRADITIONAL
    shift: 'True'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    alpha2: '0.5'
    nconnections: '2'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
    ymin: '-10'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', legacy_cudaops_fft_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0_0, '0']
- [legacy_cudaops_fft_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
